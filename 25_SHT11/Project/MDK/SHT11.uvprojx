# Keil uVision project SHT11.uvprojx, settings and files
target SHT11 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SHT11 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\App;..\..\App\Demo\Include;..\..\Board\Include;..\..\Chip\CMSIS;..\..\Chip\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/: main.c stm32f4xx_it.c Queue.c
    ../../App/Demo/Source/: Test_SHT11.c Test_IRDA.c Test_LEDBuzzer.c Test_Rain.c Test_MQ2.c
  group Board
    ../../Board/Source/: BSP_DebugUART.c BSP_Delay.c BSP_SHT11.c BSP_ADConverter.c BSP_ExtInt.c BSP_LEDBuzzer.c BSP_ServoMotor.c
  group CMSIS
    ../../Chip/CMSIS/startup/: startup_stm32f40_41xxx.s
    ../../Chip/CMSIS/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../../Chip/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Doc
    ../../Document/: Readme.txt
